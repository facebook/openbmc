FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-Add-property-SlotNumber-for-multi-host-system.patch \
"
