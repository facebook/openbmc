PRIMARY_INTERFACE = "br0"
