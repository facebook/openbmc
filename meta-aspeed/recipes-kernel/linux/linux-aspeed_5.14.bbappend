FILESEXTRAPATHS:prepend := "${THISDIR}/files/defconfig-5.14/${SOC_MODEL}:"
SRC_URI += "file://defconfig \
           "
