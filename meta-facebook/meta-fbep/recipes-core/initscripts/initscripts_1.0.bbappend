PRIMARY_INTERFACE = "usb0"
