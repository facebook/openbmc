FILESEXTRAPATHS_prepend := "${THISDIR}/files/defconfig-5.10/${SOC_MODEL}:"
SRC_URI += "file://defconfig \
           "
