FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://trousers.init.sh \
    file://trousers-udev.rules \
    file://tcsd.service \
    "
