FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " \
    file://0500-Add-gpio-names-and-mctp-device.patch \
"
