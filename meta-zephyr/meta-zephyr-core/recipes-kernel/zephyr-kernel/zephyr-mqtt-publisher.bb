inherit zephyr-sample

ZEPHYR_SRC_DIR = "${ZEPHYR_BASE}/samples/net/mqtt_publisher"
