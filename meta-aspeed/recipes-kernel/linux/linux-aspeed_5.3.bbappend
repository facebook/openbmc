FILESEXTRAPATHS_prepend := "${THISDIR}/files/defconfig-5.3/${SOC_MODEL}:"
SRC_URI += "file://defconfig \
           "
