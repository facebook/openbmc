
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

RUN_DHC6_FILE = "run-dhc6_prefix64_ncsi.sh"
