# Copyright 2015-present Facebook. All Rights Reserved.
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-netlakenext-dimm-util-remove-unsupport-PMIC-error.patch \
            "
