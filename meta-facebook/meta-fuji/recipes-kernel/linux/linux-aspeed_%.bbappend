# Copyright 2020-present Facebook. All Rights Reserved.

LINUX_VERSION_EXTENSION = "-fuji"

COMPATIBLE_MACHINE = "fuji"
