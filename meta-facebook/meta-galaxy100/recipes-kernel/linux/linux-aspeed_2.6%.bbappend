LINUX_VERSION_EXTENSION = "-galaxy100"

COMPATIBLE_MACHINE = "galaxy100"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://defconfig \
           "
