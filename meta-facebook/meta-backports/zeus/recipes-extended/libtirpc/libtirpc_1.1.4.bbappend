FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

BUILD_CFLAGS += "-fcommon"
