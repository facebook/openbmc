RDEPENDS:{PN} += " bash "
