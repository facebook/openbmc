RDEPENDS:${PN}:remove = "python"
