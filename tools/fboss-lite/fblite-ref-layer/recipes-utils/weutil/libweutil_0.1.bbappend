FILESEXTRAPATHS:prepend := "${THISDIR}/files/lib:"
LOCAL_URI += "file://eeprom.json \
              file://meta_eeprom_v4_sample.bin \
              "

