LOCAL_URI += " \
    file://meson.build \
    "
