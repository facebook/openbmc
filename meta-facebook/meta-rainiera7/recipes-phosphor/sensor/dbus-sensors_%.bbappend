EXTRA_OEMESON:append = " -Ddisable-in2-alarm-event=true"
