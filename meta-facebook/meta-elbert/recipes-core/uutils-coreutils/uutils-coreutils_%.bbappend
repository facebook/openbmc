PACKAGECONFIG:class-native = ""
PACKAGECONFIG:class-nativesdk = ""
