require eglibc-locale.inc
