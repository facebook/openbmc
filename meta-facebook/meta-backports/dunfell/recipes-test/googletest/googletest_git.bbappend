SRC_URI = "git://github.com/google/googletest.git;branch=main;protocol=https"
