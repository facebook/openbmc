FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://fbep_defconfig.append \
           "
