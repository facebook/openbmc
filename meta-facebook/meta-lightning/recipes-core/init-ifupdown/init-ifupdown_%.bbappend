FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

do_install_dhcp() {
  bbnote "Not installing dhcp for lightning"
}
