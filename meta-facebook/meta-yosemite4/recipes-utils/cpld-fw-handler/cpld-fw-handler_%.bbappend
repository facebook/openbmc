EXTRA_OEMESON:append = " -Denable-events=enabled"
