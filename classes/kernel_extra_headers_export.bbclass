inherit kernel_extra_headers_base

KERNEL_EXTRA_HEADER_PATH = "${STAGING_DIR_TARGET}${includedir}/linux-extra"
export KERNEL_EXTRA_HEADER_PATH