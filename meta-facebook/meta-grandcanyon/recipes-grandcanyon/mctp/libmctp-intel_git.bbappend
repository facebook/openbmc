FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Increase-the-size-of-smbus-tx-buffer.patch \
           "

