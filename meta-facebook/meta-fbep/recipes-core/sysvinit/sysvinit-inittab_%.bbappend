# ttyS0 is UART5, BMC's serial port
SERIAL_CONSOLES += "57600;ttyS0"
