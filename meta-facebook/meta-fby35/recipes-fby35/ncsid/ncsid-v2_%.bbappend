# Copyright 2014-present Facebook. All Rights Reserved.

CFLAGS:prepend =  " -DCONFIG_PLDM_SENSORS_DISABLE "