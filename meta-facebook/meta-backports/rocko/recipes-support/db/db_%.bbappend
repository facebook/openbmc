
MUTEX = "--with-mutex=POSIX/pthreads/library"
