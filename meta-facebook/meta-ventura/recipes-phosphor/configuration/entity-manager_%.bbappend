FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://0001-meta-ventura-drop-valve-cable-inventory.patch \
"
