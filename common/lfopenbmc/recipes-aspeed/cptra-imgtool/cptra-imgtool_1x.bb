CALIPTRA_AUTH_MANIFEST_APP = "caliptra-auth-manifest-app-1x"

require cptra-imgtool.inc
require cptra-imgtool_1x-crates.inc
require cptra-imgtool_1x-git-crates.inc
