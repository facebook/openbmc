RDEPENDS_{PN} += " bash "
