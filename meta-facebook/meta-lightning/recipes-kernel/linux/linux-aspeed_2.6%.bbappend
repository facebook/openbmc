LINUX_VERSION_EXTENSION = "-lightning"

COMPATIBLE_MACHINE = "lightning"

KERNEL_CONFIG_COMMAND = "oe_runmake lightning_defconfig && oe_runmake oldconfig"
