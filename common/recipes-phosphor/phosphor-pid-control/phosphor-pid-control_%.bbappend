FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-Auto-determine-failsafe-duty-according-sensor-fail.patch \
"

