# For qemu-system-native we need some libslirp commits that aren't in the
# recipe SRCREV yet.  Just override it.
SRCREV="c7c151fe3a2700bcabfc07235176fcedf7e9b089"
