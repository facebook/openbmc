SUMMARY = "Placeholder recipe for fbqemu in older yocto branches"
SRC_URI = ""
LOCAL_URI = ""
LIC_FILES_CHKSUM = ""
DEPENDS:class-native = ""
RDEPENDS:${PN}:class-native = ""
