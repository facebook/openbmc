FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://0001-util-enhance-MAC-address-parsing.patch \
    "
