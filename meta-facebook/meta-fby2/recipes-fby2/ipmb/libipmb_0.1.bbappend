# Copyright 2015-present Facebook. All Rights Reserved.

CFLAGS:prepend = " -DTIMEOUT_IPMB=3 "
