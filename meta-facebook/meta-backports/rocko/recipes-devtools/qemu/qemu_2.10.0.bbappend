FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://glibc.patch \
           "
