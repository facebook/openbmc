require recipes-core/images/yosemite4-image.bb

IMAGE_INSTALL:remove = " packagegroup-openbmc-tests2"
