# Copyright 2021-present Facebook. All Rights Reserved.

CFLAGS_prepend = "-DEEPROM_BUS=0x0B -DEEPROM_ADDR=0xA8"

