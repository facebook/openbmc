FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://2000-fix-dhclient-get-wrong-mac.patch \
           "
