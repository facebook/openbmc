FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://fix-dhclient-get-wrong-mac.patch \
           "
