RDEPENDS:${PN} = "tzdata-core"
