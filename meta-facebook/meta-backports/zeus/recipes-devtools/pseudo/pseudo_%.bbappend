FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-pseudo_ipc.h-Fix-enum-typedef.patch"
