FILESEXTRAPATHS:prepend := "${THISDIR}/files/defconfig-5.15/${SOC_MODEL}:"
SRC_URI += "file://defconfig \
           "
