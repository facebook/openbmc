# Copyright 2021-present Facebook. All Rights Reserved.
CFLAGS:prepend = "-DTIMEOUT_IPMB=3"
