FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Fix-compiler-warning-on-array-out-of-bounds.patch \
            file://0001-Fix-redundant-declaration-of-yylloc.patch \
           "

