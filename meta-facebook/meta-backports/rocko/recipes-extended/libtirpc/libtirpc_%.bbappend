FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Avoid-multiple-definiton-with-gcc-fno-common.patch"

