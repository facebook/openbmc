FILESEXTRAPATHS_prepend := "${THISDIR}/files/defconfig-5.4/${SOC_MODEL}:"
SRC_URI += "file://defconfig \
           "
