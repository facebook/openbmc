EXTRA_OEMESON:append = " \
  -Ddiscovery-fru-data-from-terminus=disabled \
  -Denable-fallback-terminus-name=disabled \
  -Dfw-update-pkg-inotify=enabled \
"
