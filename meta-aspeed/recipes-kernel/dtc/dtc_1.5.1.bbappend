FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Cast-void-pointer-to-a-pointer-of-uint8_t.patch"

