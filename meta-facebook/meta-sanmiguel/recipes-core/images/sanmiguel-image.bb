require common/images/fb-openbmc-image.inc
require conf/image/sanmiguel-image-extras.inc
