PACKAGECONFIG_remove = "libjitterentropy"
