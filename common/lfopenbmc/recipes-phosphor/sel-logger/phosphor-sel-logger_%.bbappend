PACKAGECONFIG:remove = "log-threshold"
