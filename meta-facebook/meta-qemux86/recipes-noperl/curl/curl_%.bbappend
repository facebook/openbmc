RDEPENDS:${PN}-ptest:remove = "\
    perl-modules \
    perl-module-time-hires \
    perl-module-digest-md5 \
    perl-module-digest \
    perl-module-ipc-open2 \
"
