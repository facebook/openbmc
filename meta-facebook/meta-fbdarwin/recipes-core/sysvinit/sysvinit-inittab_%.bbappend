# ttyS0 is UART0, connected to the front panel Console Port
SERIAL_CONSOLES = "9600;ttyS0"
