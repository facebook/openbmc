# Remove the deploy task as it conflicts with
# npcm8xx-tip-fw and npcm8xx-bootblock
deltask deploy