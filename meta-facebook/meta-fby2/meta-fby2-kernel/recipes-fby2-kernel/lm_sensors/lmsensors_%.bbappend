
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://fby2.conf \
           "
