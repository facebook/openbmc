KERNEL_MODULE_PROBECONF += " \
  pfe3000                    \
"

module_conf_pfe3000= "options pfe3000 ignore_probe=1"
