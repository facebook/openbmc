FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

EXTRA_OECMAKE:append = "-DJANSSON_BUILD_SHARED_LIBS=ON"
