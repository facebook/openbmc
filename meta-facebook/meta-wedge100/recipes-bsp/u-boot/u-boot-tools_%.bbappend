RDEPENDS:${PN}-mkimage:remove = "dtc"
