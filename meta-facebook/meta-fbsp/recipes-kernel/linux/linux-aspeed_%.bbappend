LINUX_VERSION_EXTENSION = "-fbsp"

COMPATIBLE_MACHINE = "sonorapass"

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://fbsp.cfg"
