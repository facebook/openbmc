RDEPENDS:${PN}:remove = "gdb gdbserver"
