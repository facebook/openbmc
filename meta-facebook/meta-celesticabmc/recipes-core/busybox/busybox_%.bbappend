FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://wget.cfg"
SRC_URI += "file://disable-watchdog.cfg"
