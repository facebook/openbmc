# Do not point to FB mirrors if the source is checked out from
# the public github repository.
python () {
    pass
}
