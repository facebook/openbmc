FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://fix_dup_null_ptr.patch"
