# Copyright 2015-present Facebook. All Rights Reserved.
FILESEXTRAPATHS:append := "${THISDIR}/files:"
LOCAL_URI += "file://healthd-config.json"

SRC_URI += "file://0001-netlakenext-healthd-make-log-more-detail.patch \
            "
