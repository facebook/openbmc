FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-Extend-IPMI-OEM-command-CMD_OEM_SET_PPIN_INFO-PPIN-l.patch \
    "
