# Copyright 2020-present Facebook. All Rights Reserved.

IMAGE_INSTALL:remove = " wedge-eeprom"
IMAGE_INSTALL += " \
    meta-fboss-export \
"
