# Python3 only. Override py2 packages
RDEPENDS_${PN}-bin_remove = "python-core"
RDEPENDS_${PN}-bin += "python3-core"
