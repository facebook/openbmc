FILESEXTRAPATHS:prepend := "${THISDIR}/files/pal:"

LOCAL_URI += "\
    file://plat/meson.build \
    "
