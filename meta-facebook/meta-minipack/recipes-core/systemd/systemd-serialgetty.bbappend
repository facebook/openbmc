SERIAL_CONSOLES = "9600;ttyS1 57600;ttyS2"
