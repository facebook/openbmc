FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-arble-configs-Add-fdt_high-and-initrd_high-variables.patch\
           "