LINUX_VERSION_EXTENSION = "-yosemite"

COMPATIBLE_MACHINE = "yosemite"

KERNEL_CONFIG_COMMAND = "oe_runmake yosemite_defconfig && oe_runmake oldconfig"
