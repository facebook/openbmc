FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-tcp-fix-some-compiler-warnings-with-enable-tls-opens.patch"
