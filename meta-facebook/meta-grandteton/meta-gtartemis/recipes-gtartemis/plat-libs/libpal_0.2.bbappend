CFLAGS:prepend = " -DCONFIG_ARTEMIS "

