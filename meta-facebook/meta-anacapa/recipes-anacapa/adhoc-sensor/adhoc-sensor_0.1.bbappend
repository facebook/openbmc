# The board-fallback auto-pick lands on AMD_AMC, which depends on the AMC.
CHASSIS_PATH = "/xyz/openbmc_project/inventory/system/board/MB"
