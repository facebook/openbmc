FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
# ELBERTTODO 447408 BMC trousers support

