
do_install_fake_dhclient() {
    bbnote "Don't install fake dhclient for GrandCanyon"
}
