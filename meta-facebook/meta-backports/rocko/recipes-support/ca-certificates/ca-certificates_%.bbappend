FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-certdata2pem.py-use-python3.patch \
           "
