EXTRA_OEMESON:append = "\
    -Dredfish-cpu-log=enabled \
"
