FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://fbal_defconfig.append \
           "
