FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0100-configuration-yv4-set-mctp-i3c-information-for-SD-an.patch \
"
