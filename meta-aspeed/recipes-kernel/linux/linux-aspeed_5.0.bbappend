FILESEXTRAPATHS:prepend := "${THISDIR}/files/defconfig-5.0/${SOC_MODEL}:"
SRC_URI += "file://defconfig \
           "
