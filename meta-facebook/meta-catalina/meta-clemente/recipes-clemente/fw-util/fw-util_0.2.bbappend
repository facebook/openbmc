FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

LOCAL_URI += " \
    file://plat_fwupdate.cpp \
    file://cpld.cpp \
    "
