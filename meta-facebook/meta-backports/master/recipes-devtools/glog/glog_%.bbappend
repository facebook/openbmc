PACKAGECONFIG:remove:armv6 = "64bit-atomics"
PACKAGECONFIG:remove:armv5 = "64bit-atomics"
