LINUX_VERSION_EXTENSION = "-fbtp"

COMPATIBLE_MACHINE = "fbtp"

KERNEL_MODULE_AUTOLOAD += " \
"
