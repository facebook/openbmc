EXTRA_OEMESON:append = " -Dmax-boot-cycle-count=5"