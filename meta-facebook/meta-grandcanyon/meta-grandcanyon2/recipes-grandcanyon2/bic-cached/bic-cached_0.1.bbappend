# Copyright 2020-present Facebook. All Rights Reserved.
#
# GrandCanyon 2.0 Project

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

LOCAL_URI += " \
    file://setup-bic-cached.sh \
    "
