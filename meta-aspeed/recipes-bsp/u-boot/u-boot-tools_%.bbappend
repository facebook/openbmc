RDEPENDS_${PN}_class-native_append = " dtc-native"
