
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-Include-string-for-std-string.patch \
           "
CFLAGS += "-w"
