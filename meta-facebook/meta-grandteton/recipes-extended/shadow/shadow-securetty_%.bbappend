# ttyS9 for backdoor access from host
SERIAL_CONSOLES += "ttyS9"
