# Install otp binary in a hidden location
# Hidden path: /usr/local/otp/otp

bindir = "/usr/local/otp"
