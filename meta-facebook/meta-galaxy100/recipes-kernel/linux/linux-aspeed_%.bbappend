LINUX_VERSION_EXTENSION = "-galaxy100"

COMPATIBLE_MACHINE = "galaxy100"
