
RUN_DHC6_FILE = "run-dhc6_ncsi.sh"
