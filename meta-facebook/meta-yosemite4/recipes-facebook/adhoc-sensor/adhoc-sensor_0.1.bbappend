# Yosemite 4 specific configuration for adhoc-sensor
CHASSIS_PATH = "/xyz/openbmc_project/inventory/system/chassis/Yosemite_4_Chassis"
