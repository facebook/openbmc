CFLAGS:append:qemu-x86 = " -Wno-error=implicit-function-declaration -Wno-error=implicit-int -Wno-error=return-mismatch "

