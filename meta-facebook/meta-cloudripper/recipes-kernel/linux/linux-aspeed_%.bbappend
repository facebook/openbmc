# Copyright 2020-present Facebook. All Rights Reserved.

LINUX_VERSION_EXTENSION = "-cloudripper"

COMPATIBLE_MACHINE = "cloudripper"
