# Copyright 2020-present Facebook. All Rights Reserved.

LINUX_VERSION_EXTENSION = "-grandteton"

COMPATIBLE_MACHINE = "grandteton|inspirationpoint|gtartemis"
