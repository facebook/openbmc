# Copyright 2015-present Facebook. All Rights Reserved.
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

LOCAL_URI += " \
        file://plat/meson.build \
        file://apml-plat.cpp \
        "
