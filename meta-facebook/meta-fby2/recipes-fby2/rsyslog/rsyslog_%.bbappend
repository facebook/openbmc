MTERM_LOG_FILES = "mTerm_slot1 mTerm_slot2 mTerm_slot3 mTerm_slot4"
