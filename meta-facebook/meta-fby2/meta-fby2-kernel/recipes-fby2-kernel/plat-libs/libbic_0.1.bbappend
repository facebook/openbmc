# Copyright 2015-present Facebook. All Rights Reserved.

CFLAGS:prepend = " -DCONFIG_FBY2_KERNEL "
