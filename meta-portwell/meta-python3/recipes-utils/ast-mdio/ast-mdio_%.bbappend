# Python3 only. Override py2 packages
RDEPENDS_${PN}_remove = "python"
RDEPENDS_${PN} += "python3-core"
