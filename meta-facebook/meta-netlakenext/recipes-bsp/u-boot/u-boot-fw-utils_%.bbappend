FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://facebook-netlakenext_defconfig.append \
           " 
