FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI:append:rainiera7 = " file://rainiera7.cfg"
