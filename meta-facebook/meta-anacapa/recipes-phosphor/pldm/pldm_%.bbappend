EXTRA_OEMESON:append = " \
  -Ddiscovery-fru-data-from-terminus=disabled \
  -Dsensor-polling-time=2000 \
  -Dmctp-recovery=disabled \
  -Denable-fallback-terminus-name=enabled \
  -Denable-terminus-dbus=disabled \
  -Dfw-update-pkg-inotify=enabled \
  -Dterminus-discovery-retry-count=10 \
  -Dresponse-time-out=4800 \
"
