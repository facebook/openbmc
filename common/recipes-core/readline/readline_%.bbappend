FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

PR .= ".1"
