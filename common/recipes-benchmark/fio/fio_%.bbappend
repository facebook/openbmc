# TODO T59682217 : Get this upstreamed and remove the EXTRA_OECONF below.
EXTRA_OECONF_remove = "--disable-optimizations"
