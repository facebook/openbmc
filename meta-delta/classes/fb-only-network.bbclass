# Do not restrict network downloads if the source is checked out from 
# the public github repository.
python () {
    pass
}
