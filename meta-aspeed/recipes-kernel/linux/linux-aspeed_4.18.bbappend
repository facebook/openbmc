FILESEXTRAPATHS_prepend := "${THISDIR}/files/defconfig-4.18/${SOC_MODEL}:"
SRC_URI += "file://defconfig \
           "
