FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://facebook-netlakemtp_defconfig.append \
           "
