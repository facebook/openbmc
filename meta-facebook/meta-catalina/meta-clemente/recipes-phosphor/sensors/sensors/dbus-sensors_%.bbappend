FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:append = " file://0001-Add-LM5066I-sensor-type-oprtion.patch \
"
