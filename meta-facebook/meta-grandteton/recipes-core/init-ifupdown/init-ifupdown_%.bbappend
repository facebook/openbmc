FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

NETWORK_INTERFACES = "auto/lo manual/eth0 static/ipv4/usb0"

RUN_DHC6_FILE = "run-dhc6_prefix64_ncsi.sh"
