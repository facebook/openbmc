FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://0002-src-global.c-Remove-superfluous-declaration-of-progr.patch \
    "
