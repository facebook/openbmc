require eglibc-scripts.inc
