PACKAGECONFIG:append = " oem-arm"
