FILESEXTRAPATHS:prepend := "${THISDIR}/files/prot-util:"

LOCAL_URI += " \
    file://SysCpldSettings.hpp \
    "