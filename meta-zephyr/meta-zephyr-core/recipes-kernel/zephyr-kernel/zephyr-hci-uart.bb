inherit zephyr-sample

ZEPHYR_SRC_DIR = "${ZEPHYR_BASE}/samples/bluetooth/hci_uart"

COMPATIBLE_MACHINE = "(96b-nitrogen)"
