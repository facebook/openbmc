RDEPENDS:${PN}:remove = "\
    packagegroup-openbmc-tpm\
    packagegroup-openbmc-emmc\
    packagegroup-openbmc-pfr\
    udev-rules\
    sudo\
    obmc-dump"
