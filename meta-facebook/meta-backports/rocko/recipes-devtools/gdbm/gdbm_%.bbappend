
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://gcc10.patch \
           "
