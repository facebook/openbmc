FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://9990-dhcpv6-sendvendoroption.diff \
            file://9991-ipv6-link.diff \
           "
