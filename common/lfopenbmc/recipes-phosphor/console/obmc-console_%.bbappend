FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-log-handler-Add-secondary-timestamped-logging.patch"

