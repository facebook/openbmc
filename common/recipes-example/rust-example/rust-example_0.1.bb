inherit cargo

LOCAL_URI = " \
    file://Cargo.toml \
    file://src \
"

LIC_FILES_CHKSUM = " \
    file://src/main.rs;beginline=1;endline=1;md5=7226e442a172bcf25807246d7ef1eba1 \
"

SUMMARY = "Rust example"
LICENSE = "GPL-2.0-or-later"
