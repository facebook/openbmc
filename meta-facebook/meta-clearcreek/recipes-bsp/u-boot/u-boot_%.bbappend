FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://fbcc_defconfig.append \
           "
