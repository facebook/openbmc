BBCLASSEXTEND += "native nativesdk"
