FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-Fix-the-console-log-file-does-not-rotate.patch \
"
