SERIAL_CONSOLES = "9600;ttyS0 57600;ttyS1"
