
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-disable-bus-substitution.patch \
           "
