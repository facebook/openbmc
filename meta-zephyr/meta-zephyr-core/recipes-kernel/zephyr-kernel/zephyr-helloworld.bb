SUMMARY = "Hello World Zephyr Sample"
DESCRIPTION = "A simple Zephyr application that prints 'Hello World' on the \
console"

inherit zephyr-sample

ZEPHYR_SRC_DIR = "${ZEPHYR_BASE}/samples/hello_world"
