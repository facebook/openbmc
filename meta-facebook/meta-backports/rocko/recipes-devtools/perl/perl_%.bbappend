DEPENDS += "libnsl2"
