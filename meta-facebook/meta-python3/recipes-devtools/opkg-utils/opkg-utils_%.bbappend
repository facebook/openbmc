# Python3 only. Override py2 packages
# Complete override of deps here is sub-optimal, but we don't yet have a bitbake STRING_replace method
PYTHONRDEPS = "python3 python3-shell python3-io python3-math python3-crypt python3-logging python3-fcntl python3-subprocess python3-pickle python3-compression python3-textutils python3-stringold"
