# Copyright 2015-present Facebook. All Rights Reserved.

CFLAGS_prepend = " -DCONFIG_FBTTN"

INHIBIT_PACKAGE_DEBUG_SPLIT = "1"
INHIBIT_PACKAGE_STRIP = "1"
