# ttyS0 is UART5, connected to the debug board, selected by GPIOB2
# ttyS1 is UART1, connected to uS, selected by GPIOB2
# ttyS2 is UART3, connected to the front panel Console port
# ttyS3 is UART4, used as RS485 connected as rackmon
SERIAL_CONSOLES += "57600;ttyS0 9600;ttyS2"
