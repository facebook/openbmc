require common/images/fb-openbmc-image.inc

IMAGE_INSTALL:append = " fw-util"
