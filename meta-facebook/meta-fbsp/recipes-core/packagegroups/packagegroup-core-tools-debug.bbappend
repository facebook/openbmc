RDEPENDS_${PN}_remove = "gdb"
