# ttyS0 is UART5, serial port of BMC
# ttyS4 is UART4, back door access path from Host to BMC
SERIAL_CONSOLES = "57600;ttyS0 57600;ttyS4"
