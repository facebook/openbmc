# You should only use this class if you want to build the proprietary recipes
# but do not want to have fb-only-network.  This is a very rare case.
DISTROOVERRIDES .= ":fb-proprietary-recipes"
