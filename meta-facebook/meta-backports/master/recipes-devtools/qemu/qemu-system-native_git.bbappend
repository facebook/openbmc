
PACKAGECONFIG[vnc-png] = "--enable-vnc --enable-png,--disable-vnc --disable-png,libpng"
