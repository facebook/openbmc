# ttyS5 for backdoor access from host
SERIAL_CONSOLES += "ttyS5"
