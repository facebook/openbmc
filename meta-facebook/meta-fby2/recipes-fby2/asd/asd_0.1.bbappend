# Copyright 2017-present Facebook. All Rights Reserved.

CFLAGS += " -DCONFIG_JTAG_MSG_FLOW "
