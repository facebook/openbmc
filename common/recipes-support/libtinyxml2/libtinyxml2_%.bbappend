INSANE_SKIP:${PN}-staticdev += "buildpaths"
