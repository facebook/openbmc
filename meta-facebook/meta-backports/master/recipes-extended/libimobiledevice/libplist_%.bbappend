FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-git-version-gen-Prevent-multiple-lines-of-output.patch"
