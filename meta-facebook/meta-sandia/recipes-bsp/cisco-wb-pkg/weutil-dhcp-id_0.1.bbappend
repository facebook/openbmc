RDEPENDS:${PN}:remove = "wedge-eeprom"
RDEPENDS:${PN}:append = "meta-fboss-export"
