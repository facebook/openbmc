#

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://cover.conf \
           "

