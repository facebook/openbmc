FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " file://0001-Don-t-restart-control-loops-if-the-sensor-couldn-t-b.patch"

