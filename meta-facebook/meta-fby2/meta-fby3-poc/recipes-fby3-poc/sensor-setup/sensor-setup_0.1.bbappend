FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://sensor-setup.sh"
