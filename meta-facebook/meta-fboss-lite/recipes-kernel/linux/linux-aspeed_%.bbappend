# Copyright 2022-present Facebook. All Rights Reserved.

FILESEXTRAPATHS:prepend := "${THISDIR}/kconfig:"

SRC_URI += "file://fboss_lite.cfg \
           "
