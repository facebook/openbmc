FILESEXTRAPATHS_prepend := "${THISDIR}/files/defconfig-4.17/${SOC_MODEL}:"
SRC_URI += "file://defconfig \
           "
