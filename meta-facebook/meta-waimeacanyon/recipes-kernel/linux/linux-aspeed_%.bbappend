# Copyright 2020-present Facebook. All Rights Reserved.

LINUX_VERSION_EXTENSION = "-waimeacanyon"

COMPATIBLE_MACHINE = "waimeacanyon"
