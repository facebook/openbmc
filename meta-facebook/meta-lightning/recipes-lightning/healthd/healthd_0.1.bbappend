# Copyright 2017-present Facebook. All Rights Reserved.

CFLAGS_prepend = " -DCONFIG_LIGHTNING"

INHIBIT_PACKAGE_DEBUG_SPLIT = "1"
INHIBIT_PACKAGE_STRIP = "1"
