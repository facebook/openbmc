DEPENDS:remove = "gnutls"
EXTRA_OECONF:append = " --enable-tls=no --enable-tls-openssl=yes"
