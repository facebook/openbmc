#
# Emeraldpools uses 1 Lattice CPLD
#
CFLAGS += " -DLATTICE_SUPPORT"
