FILESEXTRAPATHS_prepend := "${THISDIR}/files/:"
SRC_URI += "file://wedge400_5.3.cfg \
           "
