RDEPENDS:${PN}-ptest:remove = "perl"
