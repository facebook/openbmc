# Pickup kern-tools fixes ba600ef6..6a4752eb before they are get picked by yocto 
SRCREV = "6a4752ebbe7d242c02b3c74a5772926edd243626"
