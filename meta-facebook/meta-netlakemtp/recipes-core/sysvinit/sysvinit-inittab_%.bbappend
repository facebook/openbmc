# ttyS0 is UART5, serial port of BMC
SERIAL_CONSOLES = "9600;ttyS0"
