# Track upstream master for new device definitions (post-1.3.1).
PV = "1.3.1+git"
SRCREV = "93c117c29b1f6669bc4ceca8b84e1df06449fe33"
SRC_URI = "git://github.com/libimobiledevice/libirecovery;protocol=https;branch=master"
